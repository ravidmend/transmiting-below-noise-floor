options:
  parameters:
    generate_options: qt_gui
    id: hackathon_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: rc_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tr_gain
  id: variable
  parameters:
    value: '15'
  states: {}
- name: hackathon_decoder_0
  id: hackathon_decoder
  parameters:
    p0: '1'
    p1: '1'
    p2: '1'
    p3: '1'
    p4: '1'
  states: {}
- name: hackathon_encoder_0
  id: hackathon_encoder
  parameters:
    p0: '1'
    p1: '1'
    p2: '1'
    p3: '1'
    p4: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: center_freq
    gain0: tr_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: center_freq
    gain0: rc_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [hackathon_encoder_0, '0', qtgui_time_sink_x_0, '0']
- [hackathon_encoder_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', hackathon_decoder_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
