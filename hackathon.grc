options:
  parameters:
    generate_options: qt_gui
    id: hackathon_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: pnlen
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: rc_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tr_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '5000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2400'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: hackathon_decoder_0_0
  id: hackathon_decoder
  parameters:
    key: '0'
    msg_len: '20'
    pn_length: pnlen
    sps: sps
    thresh: '7'
  states: {}
- name: hackathon_encoder_2
  id: hackathon_encoder
  parameters:
    fs: samp_rate
    key: '0'
    pn_length: int(pnlen)
    sps: sps
    string_input: '"Hye"'
  states: {state: disabled}
- name: hackathon_encoder_2_0
  id: hackathon_encoder
  parameters:
    fs: samp_rate
    key: ''
    pn_length: pnlen
    sps: sps
    string_input: '"AAA"'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"tran"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"tran"'
    type: complex
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: tr_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rc_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_1, '0']
- [blocks_complex_to_float_0, '0', hackathon_decoder_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_1, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', hackathon_decoder_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_delay_0, '0']
- [hackathon_encoder_2, '0', blocks_float_to_complex_0, '0']
- [hackathon_encoder_2, '0', blocks_throttle2_0, '0']
- [hackathon_encoder_2_0, '0', blocks_throttle2_0_0, '0']
- [uhd_usrp_source_1, '0', blocks_multiply_const_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
