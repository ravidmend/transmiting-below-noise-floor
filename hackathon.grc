options:
  parameters:
    generate_options: qt_gui
    id: hackathon_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: pn_len
  id: variable
  parameters:
    value: int(1e3)
  states: {}
- name: rc_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(4)
  states: {}
- name: tr_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: hackathon_decoder_0_0
  id: hackathon_decoder
  parameters:
    pn_len: pn_len
    recived_amp: '1'
    sps: sps
  states: {}
- name: hackathon_encoder_2_0
  id: hackathon_encoder
  parameters:
    pn_len: pn_len
    sps: sps
    string_input: '"Hey"*1000'
  states: {}

connections:
- [blocks_throttle2_0, '0', hackathon_decoder_0_0, '0']
- [hackathon_encoder_2_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
