options:
  parameters:
    generate_options: qt_gui
    id: hackathon_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: pnlen
  id: variable
  parameters:
    value: int(1e3)
  states: {}
- name: rc_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: tr_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: hackathon_decoder_0
  id: hackathon_decoder
  parameters:
    Ts: 1/samp_rate
    fs: int(samp_rate)
    pn_len: int(pnlen)
  states: {state: disabled}
- name: hackathon_decoder_0_0
  id: hackathon_decoder
  parameters:
    Ts: 1/samp_rate
    fs: int(samp_rate)
    pn_len: int(pnlen)
  states: {}
- name: hackathon_encoder_2
  id: hackathon_encoder
  parameters:
    fs: samp_rate
    pn_length: pnlen
    sps: '20'
    string_input: '"Hye"'
  states: {state: disabled}
- name: hackathon_encoder_2_0
  id: hackathon_encoder
  parameters:
    fs: samp_rate
    pn_length: pnlen
    sps: int(4)
    string_input: '"Hey"*1000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"tran"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"tran"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"tran"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: tr_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rc_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_1, '0']
- [blocks_throttle2_0, '0', hackathon_decoder_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0_1, '0']
- [hackathon_encoder_2, '0', blocks_float_to_complex_0, '0']
- [hackathon_encoder_2_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_1, '0', hackathon_decoder_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
