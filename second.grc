options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: second
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: key
  id: variable
  parameters:
    value: '5'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pnlen
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: rc_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: snr
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tr_gain
  id: variable
  parameters:
    value: snr * noise_amp
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '24'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: hackathon_decoder_0_0_0
  id: hackathon_decoder
  parameters:
    key: key
    msg_len: '3'
    pn_length: pnlen
    sps: sps
    thresh: '0'
  states: {}
- name: hackathon_encoder_2_0
  id: hackathon_encoder
  parameters:
    fs: samp_rate
    key: key
    pn_length: int(pnlen)
    sps: sps
    string_input: '"Hey"'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0_0, '0']
- [blocks_complex_to_float_0, '0', hackathon_decoder_0_0_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_float_0, '0']
- [blocks_delay_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0_0, '0', blocks_delay_0, '0']
- [hackathon_encoder_2_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
